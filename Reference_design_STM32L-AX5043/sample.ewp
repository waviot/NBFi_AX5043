# IAR project sample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071CZ ST STM32L071CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L071xx
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: Inc; Drivers\STM32L0xx_HAL_Driver\Inc; Drivers\CMSIS\Device\ST\STM32L0xx\Include; Drivers\CMSIS\Include; ..\NBFiLib\axradio; ..\NBFiLib\libmf; ..\NBFiLib\misc; ..\NBFiLib\nbfi; Drivers\STM32L0xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.hex
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: src\stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group drivers/cmsis/device/st/STM32L0xx/include
    Drivers/CMSIS/Device/ST/STM32L0xx/Include/: stm32l071xx.h stm32l0xx.h system_stm32l0xx.h
  group drivers/cmsis/include
    Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group drivers/STM32L0xx_HAL_Driver/inc
    Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h stm32l0xx_hal_cortex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_ll_adc.h
  group drivers/STM32L0xx_HAL_Driver/inc/legacy
    Drivers/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group drivers/STM32L0xx_HAL_Driver/src
    Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_adc.c
  group inc
    Src/: adc.h
    Inc/: main.h radio.h stm32_init.h stm32l0xx_hal_conf.h stm32l0xx_it.h
  group NBFiLib/axradio
    ../NBFiLib/axradio/: ax5043.c ax5043.h axradio.h config_united.c easyax5043.c easyax5043.h
  group NBFiLib/libmf
    ../NBFiLib/libmf/: chksgnlim16.c chksgnlim32.c crc16.c crc16b.c crc16dnpmsbtable.c crc16dnptable.c crc16msb.c crc16msbtable.c crc16table.c crc32.c crc32b.c crc32msb.c crc32msbtable.c crc32table.c crc8.c crc8b.c crc8ccitt.c crc8ccittmsbtable.c crc8ccitttable.c crc8msb.c crc8onewire.c crc8onewiremsbtable.c crc8onewiretable.c crcccittmsbtable.c crcccitttable.c fmemcpy.c fmemset.c graydec8.c grayenc8.c hweight16.c hweight32.c hweight8.c libmfcrc.h libmftypes.h libmfwtimer.h pn15adv.c pn15advtable.c pn15out.c pn15outtable.c pn9.c pn9bit.c pn9bits.c pn9buf.c pn9byte.c pn9table.c rev8.c sgnlim16.c sgnlim32.c signext12.c signext16.c signext20.c signext24.c wt0.c wt01.c wtimer.c wtimer.h
  group NBFiLib/misc
    ../NBFiLib/misc/: XTEA.c XTEA.h zcode.c zcode.h
  group NBFiLib/nbfi
    ../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_defines.h nbfi_misc.c nbfi_misc.h nbfi_phy.c nbfi_phy.h rf.c rf.h
  group src
    Src/: adc.c main.c radio.c stm32_init.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
  group startup
    startup/: startup_stm32l071xx.s
