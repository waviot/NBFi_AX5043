<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EWARM\DevKit-STM32-AX5043.ewp</path>
  </project>
  <batchBuild/>
</workspace>


