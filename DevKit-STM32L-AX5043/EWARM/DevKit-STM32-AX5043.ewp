# IAR project DevKit-STM32-AX5043.ewp, settings and files
configuration DevKit-STM32-AX5043 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071CB ST STM32L071CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L071xx
  ICCARM.PreInclude: stdint.h
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\..\NBFiLib\axradio; ..\..\NBFiLib\libmf; ..\..\NBFiLib\misc; ..\..\NBFiLib\nbfi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DevKit-STM32-AX5043.hex
  ILINK.IlinkOutputFile: DevKit-STM32-AX5043.out
  ILINK.IlinkIcfFile: stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l071xx.s
  group Application/NBFiLib/axradio
    ../../NBFiLib/axradio/: ax5043.c ax5043.h axradio.h config_united.c easyax5043.c easyax5043.h
  group Application/NBFiLib/libmf
    ../../NBFiLib/libmf/: chksgnlim16.c chksgnlim32.c crc16.c crc16b.c crc16dnpmsbtable.c crc16dnptable.c crc16msb.c crc16msbtable.c crc16table.c crc32.c crc32b.c crc32msb.c crc32msbtable.c crc32table.c crc8.c crc8b.c crc8ccitt.c crc8ccittmsbtable.c crc8ccitttable.c crc8msb.c crc8onewire.c crc8onewiremsbtable.c crc8onewiretable.c crcccittmsbtable.c crcccitttable.c fmemcpy.c fmemset.c graydec8.c grayenc8.c hweight16.c hweight32.c hweight8.c libmfcrc.h libmftypes.h libmfwtimer.h pn15adv.c pn15advtable.c pn15out.c pn15outtable.c pn9.c pn9bit.c pn9bits.c pn9buf.c pn9byte.c pn9table.c rev8.c sgnlim16.c sgnlim32.c signext12.c signext16.c signext20.c signext24.c wt0.c wt01.c wtimer.c wtimer.h
  group Application/NBFiLib/misc
    ../../NBFiLib/misc/: XTEA.c XTEA.h zcode.c zcode.h zcode_e.c zcode_e.h
  group Application/NBFiLib/nbfi
    ../../NBFiLib/nbfi/: nbfi.c nbfi.h nbfi_config.c nbfi_config.h nbfi_defines.h nbfi_misc.c nbfi_misc.h nbfi_phy.c nbfi_phy.h rf.c rf.h
  group Application/User
    ../Src/: adc.c fonts.c glcd.c gui.c main.c radio.c stlcd.c stm32l0xx_hal_msp.c stm32l0xx_it.c time.c vsprintf.c waviotdvk.c main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c system_stm32l0xx.c
    ..//Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_lptim.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
